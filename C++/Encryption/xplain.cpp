/*
f(x)= x^e mod m;
Здесь используем алгоритм шифрования RSA, кратко смысл: у нас есть два ключа, публичный и закрытый. Публичный шифрует данные и передается открыто, закрытый дешифрует данные и  остается только с вами.

Представьте что я хочу отправить письмо через почту своему другу. Чтобы это сделать через шифрование, мой друг отправляет мне через почту конверт(публичный ключ) я ему получаю и кладу туда своё письмо(данные),
потом через почту отправляю своему другу, он его открывает с помощью ножниц(закрытый ключ), и получает моё сообщение (данные). <---странно(?)
Так почта не смогла прочитать моё письмо, потому что оно было в конверте (зашифрованно публичным ключом), и мой друг смог прочитать сообщение, вытащив его из конверта ножницами (закрытым ключом)
посмотри картинку, она тоже на гите 

Как же эти ключи создаются на деле?

Выбираем два случайных простых числа p и q
Вычисляем их произведение: s = p * q  
Вычисляем Ф(s) = (p-1) * (q-1)
Выбираем число k , которое меньше Ф(s) и является взаимно простым с Ф(s) (не имеющих общих делителей друг с другом, кроме 1), чтобы было сложно отгадать. Это число будем умножать на N и получим публичный ключ.
Ищем число d, обратное числу e по модулю Ф(s) .Т.е. остаток от деления (d*e) и Ф(s) должен быть равен 1. Умножив d на N получим закрытый ключ
После произведённый вычислений, у нас будут:

k и s – открытый ключ
d и s – закрытый ключ

Основная суть такой шифровки в том, что зашифровать сообщение легко, это просто возведение числа в степень, а вот без закрытого ключа почти невозможно отгадать, в какую степень мы возвели число 
*/

#include <iostream>
#include <random>
#include <cmath>

// Функция для проверки, является ли число простым
bool isPrime(int num) {
    if (num <= 1) { //числа 0 и 1 не могут быть простыми
        return false;
    }
    for (int i = 2; i <= sqrt(num); ++i) { 
        if (num % i == 0) { 
            return false;
        }
    }
    return true;
}

// Функция для генерации случайного простого числа
int generatePrime() {
    std::random_device rd;
    std::mt19937 gen(rd());
    std::uniform_int_distribution<int> dist(2, 100); 
    int num = dist(gen);
    while (!isPrime(num)) {
        num = dist(gen);
    }
    return num;
}

// Функция для вычисления наибольшего общего делителя (НОД)
int gcd(int a, int b) {
    if (b == 0) {
        return a;
    }
    return gcd(b, a % b);
}

// Функция для вычисления функции Эйлера
int eulerFunction(int p, int q) {
    return (p - 1) * (q - 1);
}

// Функция для генерации ключей
void generateKeys(int& k, int& d, int& s) {
    int p = generatePrime();
    int q = generatePrime();
    
    // Вычисление s
    s = p * q;
    
    // Вычисление функции Эйлера
    int F = eulerFunction(p, q);
    
    // Генерация числа k, меньшего F и взаимно простого с F
    std::random_device rd;
    std::mt19937 gen(rd());
    std::uniform_int_distribution<int> dist(2, F - 1);
    k = dist(gen);
    
    while (gcd(k, F) != 1) {
        k = dist(gen);
    }
    
    // Поиск числа d такого, что (d * k) mod F = 1
    for (int i = 1; i < F; ++i) {
        if ((i * k) % F == 1) {
            d = i;
            break;
        }
    }
}

// Функция для шифрования данных с использованием открытого ключа
int encrypt(int data, int k, int s) {
    int result = 1;
    
    while (k > 0) {
        if (k & 1) { //постоянно генерируем новое k, пока НОД не будет равен 1, так k будет взаимно простым с s
            result = (result * data) % s;
        }
        data = (data * data) % s;
        k >>= 1;
    }
    
    return result;
}

// Функция для дешифровки данных с использованием закрытого ключа
int decrypt(int data, int d, int s) {
    int result = 1;
    
    while (d > 0) {
        if (d & 1) {
            result = (result * data) % s;
        }
        data = (data * data) % s;
        d >>= 1;
    }
    
    return result;
}

int main() {
    int k, d, s; // Переменные для хранения ключей
    generateKeys(k, d, s); // Генерация ключей
    
    int data = 10; // Число для шифрования
    int encryptedData = encrypt(data, k, s); // Шифрование данных
    std::cout << "Зашифрованные данные: " << encryptedData << std::endl;
    
    // Отправка зашифрованных данных на станцию
    
    int decryptedData = decrypt(encryptedData, d, s); // Дешифровка данных
    std::cout << "Расшифрованные данные: " << decryptedData << std::endl;
    
    return 0;
}
